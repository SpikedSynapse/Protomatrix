# Repository SpikedSynapse/Protomatrix

File README.md:

# Protomatrix
A Keyboard matrix PCB for prototyping new keyboard ideas.

The concept of this project is to create keyboard prototyping PCB.
This a very simple matrix that includes diodes only. Each trace ends 
in a pinout that can be connected to a breadboard. 
This first version is set up as a FRL/TKL. I wanted enough keys for
things to feel complete, and still work on a Pro-Micro. Of Course
this is meant to work with any prototyping system, but Pro-Micros
are cheap.

As of right now this PCB is untested. I am awaiting prototypes and I will update this when i have tested them.

## KiCad design Protomatrix/Protomatrix.kicad_pcb

Parts:
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39, D40, D41, D42, D43, D44, D45, D46, D47, D48, D49, D50, D51, D52, D53, D54, D55, D56, D57, D58, D59, D60, D61, D62, D63, D64, D65, D66, D67, D68, D69, D70: 1N4148; D_DO-35_SOD27_P7.62mm_Horizontal
J1: Conn_01x18_Female; PinHeader_1x18_P2.54mm_Vertical
MX0, MX1, MX2, MX3, MX4, MX5, MX6, MX7, MX8, MX9: MX-NoLED; MXOnly-1U-NoLED
MX-1, MX-.1: MX-NoLED; MXOnly-1U-NoLED
MX-'1: MX-NoLED; MXOnly-1U-NoLED
MX-,1: MX-NoLED; MXOnly-1U-NoLED
MX-/1: MX-NoLED; MXOnly-1U-NoLED
MX-;1: MX-NoLED; MXOnly-1U-NoLED
MX-Bksp1: MX-NoLED; MXOnly-2U-NoLED
MX-Caps1: MX-NoLED; MXOnly-1.75U-NoLED
MX-Del1: MX-NoLED; MXOnly-1U-NoLED
MX-Down1: MX-NoLED; MXOnly-1U-NoLED
MX-E1: MX-NoLED; MXOnly-1U-NoLED
MX-Enter1: MX-NoLED; MXOnly-2.25U-NoLED
MX-Hm1: MX-NoLED; MXOnly-1U-NoLED
MX-Ins1: MX-NoLED; MXOnly-1U-NoLED
MX-LAlt1: MX-NoLED; MXOnly-1.5U-NoLED
MX-LCtrl1: MX-NoLED; MXOnly-1.5U-NoLED
MX-LShift1: MX-NoLED; MXOnly-2.25U-NoLED
MX-LSys1: MX-NoLED; MXOnly-1U-NoLED
MX-Left1: MX-NoLED; MXOnly-1U-NoLED
MX-O1: MX-NoLED; MXOnly-1U-NoLED
MX-PgDn1: MX-NoLED; MXOnly-1U-NoLED
MX-PgUp1: MX-NoLED; MXOnly-1U-NoLED
MX-Q1: MX-NoLED; MXOnly-1U-NoLED
MX-R1: MX-NoLED; MXOnly-1U-NoLED
MX-RAlt1: MX-NoLED; MXOnly-1.5U-NoLED
MX-RCtrl1: MX-NoLED; MXOnly-1.5U-NoLED
MX-RShift1: MX-NoLED; MXOnly-2.75U-NoLED
MX-RSys1: MX-NoLED; MXOnly-1U-NoLED
MX-Right1: MX-NoLED; MXOnly-1U-NoLED
MX-Spc1: MX-NoLED; MXOnly-7U-ReversedStabilizers-NoLED
MX-T1: MX-NoLED; MXOnly-1U-NoLED
MX-Tab1: MX-NoLED; MXOnly-1.5U-NoLED
MX-U1: MX-NoLED; MXOnly-1U-NoLED
MX-Up1: MX-NoLED; MXOnly-1U-NoLED
MX-W1: MX-NoLED; MXOnly-1U-NoLED
MX-Y1: MX-NoLED; MXOnly-1U-NoLED
MX-[1: MX-NoLED; MXOnly-1U-NoLED
MX-\1: MX-NoLED; MXOnly-1.5U-NoLED
MX-]1: MX-NoLED; MXOnly-1U-NoLED
MX-a1: MX-NoLED; MXOnly-1U-NoLED
MX-b1: MX-NoLED; MXOnly-1U-NoLED
MX-c1: MX-NoLED; MXOnly-1U-NoLED
MX-d1: MX-NoLED; MXOnly-1U-NoLED
MX-end1: MX-NoLED; MXOnly-1U-NoLED
MX-f1: MX-NoLED; MXOnly-1U-NoLED
MX-g1: MX-NoLED; MXOnly-1U-NoLED
MX-h1: MX-NoLED; MXOnly-1U-NoLED
MX-i1: MX-NoLED; MXOnly-1U-NoLED
MX-j1: MX-NoLED; MXOnly-1U-NoLED
MX-k1: MX-NoLED; MXOnly-1U-NoLED
MX-l1: MX-NoLED; MXOnly-1U-NoLED
MX-m1: MX-NoLED; MXOnly-1U-NoLED
MX-n1: MX-NoLED; MXOnly-1U-NoLED
MX-p1: MX-NoLED; MXOnly-1U-NoLED
MX-s1: MX-NoLED; MXOnly-1U-NoLED
MX-v1: MX-NoLED; MXOnly-1U-NoLED
MX-x1: MX-NoLED; MXOnly-1U-NoLED
MX-z1: MX-NoLED; MXOnly-1U-NoLED
MX=1: MX-NoLED; MXOnly-1U-NoLED
MX`1: MX-NoLED; MXOnly-1U-NoLED

Connections:
Col0: J1.7, MX-Caps1.1 (COL), MX-LCtrl1.1 (COL), MX-LShift1.1 (COL), MX-Tab1.1 (COL), MX`1.1 (COL)
Col1: J1.8, MX1.1 (COL), MX-LSys1.1 (COL), MX-Q1.1 (COL), MX-a1.1 (COL), MX-z1.1 (COL)
Col2: J1.9, MX2.1 (COL), MX-LAlt1.1 (COL), MX-W1.1 (COL), MX-s1.1 (COL), MX-x1.1 (COL)
Col3: J1.10, MX3.1 (COL), MX-E1.1 (COL), MX-Spc1.1 (COL), MX-c1.1 (COL), MX-d1.1 (COL)
Col4: J1.11, MX4.1 (COL), MX-R1.1 (COL), MX-RAlt1.1 (COL), MX-f1.1 (COL), MX-v1.1 (COL)
Col5: J1.12, MX5.1 (COL), MX-RSys1.1 (COL), MX-T1.1 (COL), MX-b1.1 (COL), MX-g1.1 (COL)
Col6: J1.13, MX6.1 (COL), MX-RCtrl1.1 (COL), MX-Y1.1 (COL), MX-h1.1 (COL), MX-n1.1 (COL)
Col7: J1.14, MX7.1 (COL), MX-Left1.1 (COL), MX-U1.1 (COL), MX-j1.1 (COL), MX-m1.1 (COL)
Col8: J1.15, MX8.1 (COL), MX-,1.1 (COL), MX-Down1.1 (COL), MX-i1.1 (COL), MX-k1.1 (COL)
Col9: J1.16, MX9.1 (COL), MX-.1.1 (COL), MX-O1.1 (COL), MX-Right1.1 (COL), MX-l1.1 (COL)
Col10: J1.17, MX0.1 (COL), MX-/1.1 (COL), MX-;1.1 (COL), MX-PgDn1.1 (COL), MX-p1.1 (COL)
Col11: J1.18, MX-1.1 (COL), MX-'1.1 (COL), MX-PgUp1.1 (COL), MX-RShift1.1 (COL), MX-[1.1 (COL)
Col13: J1.20, MX-Bksp1.1 (COL), MX-Del1.1 (COL), MX-Hm1.1 (COL), MX-Ins1.1 (COL), MX-\1.1 (COL)
unnamed: D1.2 (A), MX`1.2 (ROW)
unnamed: D2.2 (A), MX1.2 (ROW)
unnamed: D3.2 (A), MX2.2 (ROW)
unnamed: D4.2 (A), MX3.2 (ROW)
unnamed: D5.2 (A), MX4.2 (ROW)
unnamed: D6.2 (A), MX5.2 (ROW)
unnamed: D7.2 (A), MX6.2 (ROW)
unnamed: D8.2 (A), MX7.2 (ROW)
unnamed: D9.2 (A), MX8.2 (ROW)
unnamed: D10.2 (A), MX9.2 (ROW)
unnamed: D11.2 (A), MX0.2 (ROW)
unnamed: D12.2 (A), MX-1.2 (ROW)
unnamed: D13.2 (A), MX=1.2 (ROW)
unnamed: D14.2 (A), MX-Bksp1.2 (ROW)
unnamed: D15.2 (A), MX-Ins1.2 (ROW)
unnamed: D16.2 (A), MX-Hm1.2 (ROW)
unnamed: D17.2 (A), MX-PgUp1.2 (ROW)
unnamed: D18.2 (A), MX-Q1.2 (ROW)
unnamed: D19.2 (A), MX-W1.2 (ROW)
unnamed: D20.2 (A), MX-E1.2 (ROW)
unnamed: D21.2 (A), MX-R1.2 (ROW)
unnamed: D22.2 (A), MX-T1.2 (ROW)
unnamed: D23.2 (A), MX-Y1.2 (ROW)
unnamed: D24.2 (A), MX-U1.2 (ROW)
unnamed: D25.2 (A), MX-i1.2 (ROW)
unnamed: D26.2 (A), MX-O1.2 (ROW)
unnamed: D27.2 (A), MX-p1.2 (ROW)
unnamed: D28.2 (A), MX-[1.2 (ROW)
unnamed: D29.2 (A), MX-]1.2 (ROW)
unnamed: D30.2 (A), MX-\1.2 (ROW)
unnamed: D31.2 (A), MX-Del1.2 (ROW)
unnamed: D32.2 (A), MX-end1.2 (ROW)
unnamed: D33.2 (A), MX-PgDn1.2 (ROW)
unnamed: D34.2 (A), MX-Tab1.2 (ROW)
unnamed: D35.2 (A), MX-Caps1.2 (ROW)
unnamed: D36.2 (A), MX-a1.2 (ROW)
unnamed: D37.2 (A), MX-s1.2 (ROW)
unnamed: D38.2 (A), MX-d1.2 (ROW)
unnamed: D39.2 (A), MX-f1.2 (ROW)
unnamed: D40.2 (A), MX-g1.2 (ROW)
unnamed: D41.2 (A), MX-h1.2 (ROW)
unnamed: D42.2 (A), MX-j1.2 (ROW)
unnamed: D43.2 (A), MX-k1.2 (ROW)
unnamed: D44.2 (A), MX-l1.2 (ROW)
unnamed: D45.2 (A), MX-;1.2 (ROW)
unnamed: D46.2 (A), MX-'1.2 (ROW)
unnamed: D47.2 (A), MX-Enter1.2 (ROW)
unnamed: D48.2 (A), MX-LShift1.2 (ROW)
unnamed: D49.2 (A), MX-z1.2 (ROW)
unnamed: D50.2 (A), MX-x1.2 (ROW)
unnamed: D51.2 (A), MX-c1.2 (ROW)
unnamed: D52.2 (A), MX-v1.2 (ROW)
unnamed: D53.2 (A), MX-b1.2 (ROW)
unnamed: D54.2 (A), MX-n1.2 (ROW)
unnamed: D55.2 (A), MX-m1.2 (ROW)
unnamed: D56.2 (A), MX-,1.2 (ROW)
unnamed: D57.2 (A), MX-.1.2 (ROW)
unnamed: D58.2 (A), MX-/1.2 (ROW)
unnamed: D59.2 (A), MX-RShift1.2 (ROW)
unnamed: D60.2 (A), MX-Up1.2 (ROW)
unnamed: D61.2 (A), MX-LCtrl1.2 (ROW)
unnamed: D62.2 (A), MX-LSys1.2 (ROW)
unnamed: D63.2 (A), MX-LAlt1.2 (ROW)
unnamed: D64.2 (A), MX-Spc1.2 (ROW)
unnamed: D65.2 (A), MX-RAlt1.2 (ROW)
unnamed: D66.2 (A), MX-RSys1.2 (ROW)
unnamed: D67.2 (A), MX-RCtrl1.2 (ROW)
unnamed: D68.2 (A), MX-Left1.2 (ROW)
unnamed: D69.2 (A), MX-Down1.2 (ROW)
unnamed: D70.2 (A), MX-Right1.2 (ROW)
Row0: D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), D11.1 (K), D12.1 (K), D13.1 (K), D14.1 (K), J1.1
Row1: D18.1 (K), D19.1 (K), D20.1 (K), D21.1 (K), D22.1 (K), D23.1 (K), D24.1 (K), D25.1 (K), D26.1 (K), D27.1 (K), D28.1 (K), D29.1 (K), D30.1 (K), D34.1 (K), J1.2
Row2: D15.1 (K), D35.1 (K), D36.1 (K), D37.1 (K), D38.1 (K), D39.1 (K), D40.1 (K), D41.1 (K), D42.1 (K), D43.1 (K), D44.1 (K), D45.1 (K), D46.1 (K), D47.1 (K), J1.3
Row3: D31.1 (K), D48.1 (K), D49.1 (K), D50.1 (K), D51.1 (K), D52.1 (K), D53.1 (K), D54.1 (K), D55.1 (K), D56.1 (K), D57.1 (K), D58.1 (K), D59.1 (K), D60.1 (K), J1.4
Row4: D16.1 (K), D17.1 (K), D32.1 (K), D33.1 (K), D61.1 (K), D62.1 (K), D63.1 (K), D64.1 (K), D65.1 (K), D66.1 (K), D67.1 (K), D68.1 (K), D69.1 (K), D70.1 (K), J1.5

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
Board: 2 copper layers, 359.6 x 142.1 mm, 141 parts (0 on the bottom side), 89 nets.

## Commit log

2020-11-23 Preparing KiCAD
2020-11-23 Add submodules
2020-11-23 UpdateSchematic
2020-11-24 Routing and stuff
2020-11-24 more updates
2020-11-25 routing & more
2020-11-26 The Routing Continues
2020-11-27 Version 0.1 Complete
2020-11-27 Minor Housekeeping
2020-11-27 Minor Updates
